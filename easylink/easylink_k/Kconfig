## easylink/easylink_k/Kconfig
```kconfig
menu "Easylink netlink"
config EASYLINK
        tristate "easylink support"
	help
	easylink based on netlink

endmenu
```
